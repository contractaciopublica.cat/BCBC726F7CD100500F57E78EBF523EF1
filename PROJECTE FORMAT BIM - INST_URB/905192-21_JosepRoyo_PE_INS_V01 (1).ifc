Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 905192/21
Time: 2022-11-28T19:44:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 28 19:44:46 2022 * Host: ESITEC-PC8 * Database: C:\Users\ESITEC~1\AppData\Local\Temp\9d557444-4d3d-4e80-9062-14d5c1103d9a\ae1196bf-6b6d-4f92-8001-0ba4ade25541\ifc * Database version: 5507 * Database creation date: Mon Nov 28 19:44:36 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 28 19:44:36 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 28 19:44:36 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 905192/21
LongName: REURBANITZACIÓ DEL CARRER JOSEP ROYO, ENTRE EL C/ BOGATELL I EL C/ RICART; Phase: Estat del Projecte
0 AMB.Informacio Projecte - 003.AMB.NomProjecte: REURBANITZACIÓ DEL CARRER JOSEP ROYO, ENTRE EL C/ BOGATELL I EL C/ RICART; 004.AMB.FaseProjecte: Estat del Projecte; 009.AMB.Municipi: SANT ADRIÀ DEL BESÒS

# IfcSite, Default
RefLatitude: 41, 25, 53, 810119; RefLongitude: 2, 12, 58, 783893; RefElevation: 0 m
Pset_ProductRequirements - Category: Project Information
0 AMB.Informacio Projecte - 009.AMB.Municipi: SANT ADRIÀ DEL BESÒS

# IfcSite: AMB_Reixa_Adaptativa_Meridian:AMB_Reixa_30x80 (19)
Material: <Unnamed>
Pset_ProductRequirements - Category: Site
Name (AMB_Reixa_Adaptativa_Meridian:AMB_Reixa_30x80:...)
222052
222055
222196
222199
222600
222605
228348
228351
235403
235406
248824
248827
251877
254844
255120
262046
262049
262065
262068

# IfcSite: AMB_Tapa_Adaptativa:AMB_EP_Tapa_60x60 (26)
Material: AMB.Metall.Acer.Lacat.Negre, <Unnamed>
Pset_ProductRequirements - Category: Site
Name (AMB_Tapa_Adaptativa:AMB_EP_Tapa_60x60:...)
189791
189906
192922
192934
192946
192958
211413
211484
212599
274430
326204
327439
329270
330386
337737
341394
357434
357443
358766
358829
361926
447234
447458
533487
540768
541109

# IfcSite: AMB_Tapa_Adaptativa:AMB_EP_Tapa_Circ_60cm (11)
Material: AMB.Metall.Acer.Lacat.Negre, <Unnamed>
Pset_ProductRequirements - Category: Site
Name (AMB_Tapa_Adaptativa:AMB_EP_Tapa_Circ_60cm:...)
132770
214727
242807
251396
256317
259971
262942
263762
480129
482752
640223

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2
Pset_ProductRequirements - Category: Project Information
0 AMB.Informacio Projecte - 009.AMB.Municipi: SANT ADRIÀ DEL BESÒS

# IfcBuildingStorey: Level:Level 1 (2)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = 106.AMB.Nom | Elevation (m)
N00 (mar) | N00 (mar) | 0
Drenatge i Clavagueram | Drenatge i Clavagueram | 10

# IfcBuildingElementProxy: AMB_Canal amb reixa_Adaptativa:K0013-N (16)
In: Drenatge i Clavagueram
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.20; 105.AMB.ClassificacioDescripcio: Reixes i buneras
Classification: 70.40.30.20 Reixes i buneras (Uniformat); Material: <Unnamed>, Steel
Pset_BuildingElementProxyCommon - Reference: AMB_Canal amb reixa_Adaptativa:K0013-N; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Canal amb reixa_Adaptativa: K0013-N; 110.AMB.Descripcio: SN-Reixa canal; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
5 AMB.Geometria - 507.AMB.Area: 0.0734541 m2; 509.AMB.Volum: 0.000185476 m3
Name (AMB_Canal amb reixa_Adaptativa:K0013-N:...)
240858
240862
240867
240872
240877
240882
240887
240892
240897
240902
240907
240912
240917
240922
240927
240932

# IfcBuildingElementProxy: AMB_Conversió_Aeri:AMB_EDE_Conversió_2.5m (2)
In: Drenatge i Clavagueram
Type - Material: AMB.Metall.Acer.Galvanitzat
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 109.AMB.CodiTipus: EDE_Conversió; 111.AMB.DescripcioTipus: Tub d'acer galvanitzat conversió aeri soterrat segons
Type - 5 AMB.Geometria - 503.AMB.Altura: 2.5 m
Material: <Unnamed>, AMB.Metall.Acer.Galvanitzat; Group: Sanejament - Col·lector nou 23
Pset_BuildingElementProxyCommon - Reference: AMB_Conversió_Aeri:AMB_EDE_Conversió_2.5m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Conversió_Aeri: AMB_EDE_Conversió_2.5m; 110.AMB.Descripcio: Telef-Muntant; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
5 AMB.Geometria - 507.AMB.Area: 0.89722 m2; 509.AMB.Volum: 0.0044776 m3
Name (AMB_Conversió_Aeri:AMB_EDE_Conversió_2.5m:...)
441953
446403

# IfcBuildingElementProxy: AMB_Unió_Embocadura_Variable_L2:Estándar 2 (12)
In: Drenatge i Clavagueram
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Generic Models
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.20; 105.AMB.ClassificacioDescripcio: Reixes i buneras
Classification: 70.40.30.20 Reixes i buneras (Uniformat)
Pset_BuildingElementProxyCommon - Reference: AMB_Unió_Embocadura_Variable_L2:Estándar 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Unió_Embocadura_Variable_L2: Estándar 2; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
5 AMB.Geometria - 503.AMB.Altura: 0.001 m; 509.AMB.Volum: 0.0000779274 m3
Name (AMB_Unió_Embocadura_Variable_L2:Estándar 2:...) | 507.AMB.Area (m2)
252467 | 0.333594
252468 | 0.333102
252469 | 0.333727
252470 | 0.333794
253732 | 0.333594
253733 | 0.333102
253734 | 0.333727
253735 | 0.333794
255115 | 0.333594
255116 | 0.333102
255117 | 0.333727
255118 | 0.333794

# IfcDistributionPort (1093)
Description: Flow
Name | FlowDirection
2 x Port_127529 | SOURCEANDSINK | Group: Sanejament - Col·lector existent 1
2 x Port_127547 | SOURCEANDSINK | Group: Sanejament - Col·lector existent 2
2 x Port_127565 | SOURCEANDSINK | Group: Sanejament - Col·lector existent 3
2 x Port_135510 | SOURCEANDSINK | Group: Sanejament - Pous i col·lector 1
2 x Port_136951 | SOURCEANDSINK | Group: Sanejament - Pous i col·lector 2
2 x Port_177979 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 2
2 x Port_178258 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 4
2 x InPort_184319 | SOURCEANDSINK | Group: Sanitary 13
OutPort_191075 | SOURCEANDSINK | Group: Sanitary 13
OutPort_193522 | SOURCEANDSINK | Group: Sanitary 13
4 x Port_189601 | SOURCEANDSINK
4 x Port_189905 | SOURCEANDSINK
InPort_191075 | SOURCEANDSINK | Group: Sanitary 13
OutPort_191077 | SOURCEANDSINK | Group: Sanitary 13
InPort_191077 | SOURCEANDSINK | Group: Sanitary 13
OutPort_191083 | SOURCEANDSINK | Group: Sanitary 13
InPort_191083 | SOURCEANDSINK | Group: Sanitary 13
2 x OutPort_191115 | SOURCEANDSINK | Group: Sanitary 13
2 x InPort_191095 | SOURCEANDSINK | Group: Sanitary 13
2 x OutPort_191109 | SOURCEANDSINK | Group: Sanitary 13
InPort_191107 | SOURCEANDSINK | Group: Sanitary 13
Port_191107 | SOURCEANDSINK | Group: Sanitary 13
2 x InPort_191141 | SOURCEANDSINK | Group: Sanitary 6
OutPort_503182 | SOURCEANDSINK | Group: Sanitary 6
OutPort_191242 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_191162 | SOURCEANDSINK | Group: Sanitary 6
OutPort_191304 | SOURCEANDSINK | Group: Sanitary 6
OutPort_191276 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_191181 | SOURCEANDSINK | Group: Sanitary 6
OutPort_191353 | SOURCEANDSINK | Group: Sanitary 6
OutPort_208608 | SOURCEANDSINK | Group: Sanitary 6
Port_191194 | SOURCEANDSINK | Group: Sanitary 6
InPort_191194 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_503207 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_191231 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_191244 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_191261 | SOURCEANDSINK | Group: Sanitary 6
InPort_191242 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_191248 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_191284 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_191264 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_191278 | SOURCEANDSINK | Group: Sanitary 6
InPort_191276 | SOURCEANDSINK | Group: Sanitary 6
3 x InPort_191293 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_191319 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_506837 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_191306 | SOURCEANDSINK | Group: Sanitary 6
InPort_191304 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_191309 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_191363 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_191322 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_191365 | SOURCEANDSINK | Group: Sanitary 6
InPort_191353 | SOURCEANDSINK | Group: Sanitary 6
4 x Port_192921 | SOURCEANDSINK
4 x Port_192933 | SOURCEANDSINK
4 x Port_192945 | SOURCEANDSINK
4 x Port_192957 | SOURCEANDSINK
InPort_193522 | SOURCEANDSINK | Group: Sanitary 13
2 x OutPort_193795 | SOURCEANDSINK | Group: Sanitary 13
2 x InPort_193784 | SOURCEANDSINK | Group: Sanitary 13
2 x OutPort_193816 | SOURCEANDSINK | Group: Sanitary 13
2 x InPort_193797 | SOURCEANDSINK | Group: Sanitary 13
2 x OutPort_516846 | SOURCEANDSINK | Group: Sanitary 13
InPort_193888 | SOURCEANDSINK | Group: Sanitary 11
2 x OutPort_279518 | SOURCEANDSINK | Group: Sanitary 11
Port_193888 | SOURCEANDSINK | Group: Sanitary 11
InPort_201979 | SINK | Group: IF.Altres 1
OutPort_201191 | SOURCE | Group: IF.Altres 1
2 x InPort_201603 | SOURCEANDSINK | Group: Sanitary 11
2 x OutPort_279516 | SOURCEANDSINK | Group: Sanitary 11
2 x InPort_201621 | SOURCEANDSINK | Group: Sanitary 11
2 x OutPort_201654 | SOURCEANDSINK | Group: Sanitary 11
2 x InPort_201641 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201667 | SOURCEANDSINK | Group: Sanitary 11
InPort_201667 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201669 | SOURCEANDSINK | Group: Sanitary 11
InPort_201669 | SOURCEANDSINK | Group: Sanitary 11
2 x OutPort_201699 | SOURCEANDSINK | Group: Sanitary 11
2 x InPort_201689 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201708 | SOURCEANDSINK | Group: Sanitary 11
InPort_201708 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201719 | SOURCEANDSINK | Group: Sanitary 11
InPort_201719 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201735 | SOURCEANDSINK | Group: Sanitary 11
InPort_201735 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201752 | SOURCEANDSINK | Group: Sanitary 11
InPort_201752 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201766 | SOURCEANDSINK | Group: Sanitary 11
InPort_201766 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201769 | SOURCEANDSINK | Group: Sanitary 11
InPort_201769 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201791 | SOURCEANDSINK | Group: Sanitary 11
InPort_201791 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201794 | SOURCEANDSINK | Group: Sanitary 11
InPort_201794 | SOURCEANDSINK | Group: Sanitary 11
2 x OutPort_201808 | SOURCEANDSINK | Group: Sanitary 11
2 x InPort_201802 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201817 | SOURCEANDSINK | Group: Sanitary 11
InPort_201817 | SOURCEANDSINK | Group: Sanitary 11
OutPort_201820 | SOURCEANDSINK | Group: Sanitary 11
InPort_201820 | SOURCEANDSINK | Group: Sanitary 11
2 x OutPort_201834 | SOURCEANDSINK | Group: Sanitary 11
2 x InPort_201828 | SOURCEANDSINK | Group: Sanitary 11
2 x OutPort_201843 | SOURCEANDSINK | Group: Sanitary 11
2 x InPort_201837 | SOURCEANDSINK | Group: Sanitary 11
OutPort_204611 | SOURCEANDSINK | Group: Sanitary 11
InPort_201979 | SOURCEANDSINK | Group: IF.Altres 1
2 x OutPort_201995 | SOURCEANDSINK | Group: IF.Altres 1
2 x InPort_201987 | SOURCEANDSINK | Group: IF.Altres 1
2 x OutPort_202003 | SOURCEANDSINK | Group: IF.Altres 1
2 x InPort_201997 | SOURCEANDSINK | Group: IF.Altres 1
2 x OutPort_202014 | SOURCEANDSINK | Group: IF.Altres 1
2 x InPort_202006 | SOURCEANDSINK | Group: IF.Altres 1
2 x OutPort_284059 | SOURCEANDSINK | Group: IF.Altres 1
Port_202017 | SOURCEANDSINK | Group: IF.Altres 1
InPort_202017 | SOURCEANDSINK | Group: IF.Altres 1
InPort_206536 | SINK | Group: IF.Altres 2
OutPort_202145 | SOURCE | Group: IF.Altres 2
InPort_202259 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_281967 | SOURCEANDSINK | Group: Sanitary 6
Port_202259 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_202339 | SOURCEANDSINK | Group: Sanitary 3
OutPort_203338 | SOURCEANDSINK | Group: Sanitary 3
OutPort_202514 | SOURCEANDSINK | Group: Sanitary 3
2 x InPort_202498 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_280467 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_202516 | SOURCEANDSINK | Group: Sanitary 3
InPort_202514 | SOURCEANDSINK | Group: Sanitary 3
2 x InPort_202767 | SOURCEANDSINK | Group: Sanitary 3
OutPort_203786 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_203392 | SOURCEANDSINK | Group: Sanitary 3
2 x InPort_202919 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_203379 | SOURCEANDSINK | Group: Sanitary 3
OutPort_202965 | SOURCEANDSINK | Group: Sanitary 3
InPort_202965 | SOURCEANDSINK | Group: Sanitary 3
2 x InPort_203327 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_203375 | SOURCEANDSINK | Group: Sanitary 3
InPort_203338 | SOURCEANDSINK | Group: Sanitary 3
2 x InPort_203488 | SOURCEANDSINK | Group: Sanitary 3
OutPort_203600 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_203794 | SOURCEANDSINK | Group: Sanitary 3
InPort_203600 | SOURCEANDSINK | Group: Sanitary 3
OutPort_212549 | SOURCEANDSINK | Group: Sanitary 3
2 x InPort_203775 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_203799 | SOURCEANDSINK | Group: Sanitary 3
InPort_203786 | SOURCEANDSINK | Group: Sanitary 3
InPort_204611 | SOURCEANDSINK | Group: Sanitary 11
OutPort_209805 | SOURCEANDSINK | Group: Sanitary 11
InPort_206558 | SINK | Group: IF.Altres 2
OutPort_206536 | SOURCE | Group: IF.Altres 2
InPort_206571 | SINK | Group: IF.Altres 2
OutPort_206544 | SOURCE | Group: IF.Altres 2
InPort_206544 | SINK | Group: IF.Altres 2
OutPort_206558 | SOURCE | Group: IF.Altres 2
InPort_206562 | SINK | Group: IF.Altres 2
OutPort_206571 | SOURCE | Group: IF.Altres 2
InPort_206989 | SINK | Group: IF.Altres 2
OutPort_206562 | SOURCE | Group: IF.Altres 2
InPort_206993 | SINK | Group: IF.Altres 2
OutPort_206792 | SOURCE | Group: IF.Altres 2
InPort_206792 | SINK | Group: IF.Altres 2
OutPort_206989 | SOURCE | Group: IF.Altres 2
InPort_206963 | SINK | Group: IF.Altres 2
OutPort_206973 | SOURCE | Group: IF.Altres 2
InPort_206971 | SINK | Group: IF.Altres 2
OutPort_206963 | SOURCE | Group: IF.Altres 2
InPort_206973 | SINK | Group: IF.Altres 2
OutPort_206964 | SOURCE | Group: IF.Altres 2
InPort_206964 | SINK | Group: IF.Altres 2
OutPort_206977 | SOURCE | Group: IF.Altres 2
InPort_206977 | SINK | Group: IF.Altres 2
OutPort_206965 | SOURCE | Group: IF.Altres 2
InPort_206965 | SINK | Group: IF.Altres 2
OutPort_206993 | SOURCE | Group: IF.Altres 2
InPort_209805 | SINK | Group: Sanitary 11
OutPort_206971 | SOURCE | Group: Sanitary 11
Port_208006 | SINK | Group: IF.Altres 3
InPort_208608 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_208808 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_208746 | SOURCEANDSINK | Group: Sanitary 6
Port_209805 | SOURCEANDSINK | Group: Sanitary 11
Port_210262 | SOURCEANDSINK | Group: Sanitary 14
InPort_210262 | SOURCEANDSINK | Group: Sanitary 14
2 x OutPort_283082 | SOURCEANDSINK | Group: Sanitary 14
2 x InPort_210271 | SOURCEANDSINK | Group: Sanitary 14
2 x OutPort_281993 | SOURCEANDSINK | Group: Sanitary 14
InPort_210388 | SOURCEANDSINK | Group: Sanitary 31
2 x OutPort_614297 | SOURCEANDSINK | Group: Sanitary 31
Port_210388 | SOURCEANDSINK | Group: Sanitary 31
InPort_210398 | SINK | Group: Sanitary 32
OutPort_286859 | SOURCE | Group: Sanitary 32
InPort_287129 | SINK | Group: Sanitary 32
OutPort_210398 | SOURCE | Group: Sanitary 32
Port_211153 | SOURCEANDSINK | Group: IF.Altres 3
InPort_211153 | SINK | Group: IF.Altres 3
OutPort_282937 | SOURCE | Group: IF.Altres 3
4 x Port_211412 | SOURCEANDSINK
4 x Port_211483 | SOURCEANDSINK
InPort_211947 | SOURCEANDSINK | Group: Sanitary 14
Port_211947 | SOURCEANDSINK | Group: Sanitary 14
2 x InPort_211955 | SOURCEANDSINK | Group: Sanitary 31
2 x OutPort_211972 | SOURCEANDSINK | Group: Sanitary 31
OutPort_211963 | SOURCEANDSINK | Group: Sanitary 31
Port_211963 | SOURCEANDSINK | Group: Sanitary 31
2 x InPort_211966 | SOURCEANDSINK | Group: Sanitary 31
2 x OutPort_614291 | SOURCEANDSINK | Group: Sanitary 31
Port_212111 | SOURCEANDSINK | Group: Sanitary 12
InPort_212111 | SOURCEANDSINK | Group: Sanitary 12
OutPort_212153 | SOURCEANDSINK | Group: Sanitary 12
Port_212153 | SOURCEANDSINK | Group: Sanitary 12
2 x InPort_212538 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_279065 | SOURCEANDSINK | Group: Sanitary 3
2 x OutPort_212551 | SOURCEANDSINK | Group: Sanitary 3
InPort_212549 | SOURCEANDSINK | Group: Sanitary 3
InPort_212566 | SOURCEANDSINK | Group: Sanitary 3
Port_212566 | SOURCEANDSINK | Group: Sanitary 3
4 x Port_212598 | SOURCEANDSINK
2 x InPort_212709 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_506833 | SOURCEANDSINK | Group: Sanitary 6
Port_213079 | SOURCEANDSINK | Group: Sanitary 6
InPort_213079 | SOURCEANDSINK | Group: Sanitary 6
Port_213154 | SOURCEANDSINK | Group: Sanitary 7
InPort_213154 | SOURCEANDSINK | Group: Sanitary 7
2 x OutPort_511047 | SOURCEANDSINK | Group: Sanitary 7
2 x InPort_213384 | SOURCEANDSINK | Group: Sanitary 7
2 x OutPort_511028 | SOURCEANDSINK | Group: Sanitary 7
2 x OutPort_511026 | SOURCEANDSINK | Group: Sanitary 7
2 x InPort_213402 | SOURCEANDSINK | Group: Sanitary 7
2 x InPort_213405 | SOURCEANDSINK | Group: Sanitary 7
2 x OutPort_511070 | SOURCEANDSINK | Group: Sanitary 7
2 x OutPort_511068 | SOURCEANDSINK | Group: Sanitary 7
2 x InPort_213651 | SOURCEANDSINK | Group: Sanitary 7
Port_213700 | SOURCEANDSINK | Group: Sanitary 7
InPort_213700 | SOURCEANDSINK | Group: Sanitary 7
2 x OutPort_511098 | SOURCEANDSINK | Group: Sanitary 7
2 x InPort_213711 | SOURCEANDSINK | Group: Sanitary 7
2 x Port_214487 | SOURCEANDSINK | Group: Sanitary 2
2 x Port_223291 | SOURCEANDSINK | Group: Sanitary 1
5 x Port_226588 | SOURCEANDSINK
5 x Port_227705 | SOURCEANDSINK
5 x Port_228031 | SOURCEANDSINK
3 x Port_228546 | SOURCEANDSINK
Port_228546 | SOURCEANDSINK | Group: Sanitary 5
Port_228546 | SOURCEANDSINK | Group: Sanitary 1
Port_230296 | SOURCEANDSINK | Group: Sanitary 18
Port_230296 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 3
5 x Port_230296 | SOURCEANDSINK
Port_230296 | SOURCEANDSINK | Group: IF.SANE.Pluvial 7
5 x Port_230644 | SOURCEANDSINK
Port_230644 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 1
Port_230644 | SOURCEANDSINK | Group: IF.SANE.Pluvial 2
Port_230644 | SOURCEANDSINK | Group: Sanitary 16
2 x Port_235063 | SOURCEANDSINK | Group: Sanitary 17
5 x Port_235409 | SOURCEANDSINK
Port_242810 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 5
5 x Port_242810 | SOURCEANDSINK
Port_242810 | SOURCEANDSINK | Group: Sanitary 4
Port_242810 | SOURCEANDSINK | Group: IF.SANE.Pluvial 3
2 x Port_244039 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 7
2 x Port_244456 | SOURCEANDSINK | Group: Sanitary 19
5 x Port_246415 | SOURCEANDSINK
2 x Port_249013 | SOURCEANDSINK | Group: Sanitary 43
5 x Port_249826 | SOURCEANDSINK
Port_249826 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 8
Port_249826 | SOURCEANDSINK | Group: IF.SANE.Pluvial 1
Port_249826 | SOURCEANDSINK | Group: Sanitary 24
4 x Port_252466 | SOURCEANDSINK
Port_252466 | SOURCEANDSINK | Group: Sanitary 10
2 x Port_253014 | SOURCEANDSINK | Group: Sanitary 10
5 x Port_253731 | SOURCEANDSINK
2 x Port_254925 | SOURCEANDSINK | Group: Sanitary 25
2 x Port_255019 | SOURCEANDSINK | Group: Sanitary 8
5 x Port_255114 | SOURCEANDSINK
Port_255589 | SOURCEANDSINK | Group: Sanitary 26
4 x Port_255589 | SOURCEANDSINK
Port_255589 | SOURCEANDSINK | Group: IF.SANE.Pluvial 6
Port_255589 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 9
Port_255589 | SOURCEANDSINK | Group: Sanejament - Pous i col·lector 1
2 x Port_256998 | SOURCEANDSINK | Group: Sanitary 20
Port_257688 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 11
4 x Port_257688 | SOURCEANDSINK
Port_257688 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 10
Port_257688 | SOURCEANDSINK | Group: IF.SANE.Pluvial 8
Port_257688 | SOURCEANDSINK | Group: Sanitary 28
2 x Port_258459 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 12
5 x Port_260924 | SOURCEANDSINK
2 x Port_261081 | SOURCEANDSINK | Group: Sanitary 9
5 x Port_261247 | SOURCEANDSINK
2 x Port_262278 | SOURCEANDSINK | Group: Sanitary 29
8 x Port_262787 | SOURCEANDSINK
Port_263070 | SOURCEANDSINK | Group: IF.SANE.Pluvial 5
5 x Port_263070 | SOURCEANDSINK
Port_263070 | SOURCEANDSINK | Group: Sanitary 30
Port_263070 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 13
2 x Port_264421 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 14
2 x Port_264725 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 15
2 x Port_264750 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 16
InPort_264756 | SINK | Group: Sanejament - Col·lector nou 17
OutPort_271116 | SOURCE | Group: Sanejament - Col·lector nou 17
Port_264756 | SINK | Group: Sanejament - Col·lector nou 17
4 x Port_271116 | SOURCEANDSINK
InPort_277700 | SINK | Group: Sanejament - Col·lector nou 18
2 x OutPort_271116 | SOURCE | Group: Sanejament - Col·lector nou 18
5 x Port_271116 | SOURCEANDSINK | Group: Hydronic Supply 2
InPort_274627 | SINK | Group: Sanejament - Col·lector nou 18
2 x InPort_274925 | SINK | Group: Sanejament - Col·lector nou 18
OutPort_274627 | SOURCE | Group: Sanejament - Col·lector nou 18
5 x Port_274925 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 18
InPort_274925 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 18
OutPort_278677 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 18
4 x Port_274925 | SOURCEANDSINK
OutPort_277700 | SOURCE | Group: Sanejament - Col·lector nou 18
InPort_277728 | SOURCEANDSINK | Group: Sanitary 3
Port_277728 | SOURCEANDSINK | Group: Sanitary 3
2 x InPort_277785 | SOURCEANDSINK | Group: Sanitary 31
Port_278677 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 18
2 x Port_278778 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 19
2 x Port_278915 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 20
2 x Port_278920 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 21
2 x Port_278937 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 22
2 x Port_280469 | SOURCEANDSINK | Group: Sanitary 23
InPort_286859 | SINK | Group: Sanitary 32
OutPort_282843 | SOURCE | Group: Sanitary 32
InPort_282843 | SINK | Group: Sanitary 32
OutPort_282937 | SOURCE | Group: Sanitary 32
2 x Port_284855 | SOURCEANDSINK | Group: Sanitary 33
2 x Port_285600 | SOURCEANDSINK | Group: Sanitary 35
Port_285890 | SOURCEANDSINK | Group: Sanitary 38
InPort_285890 | SOURCEANDSINK | Group: Sanitary 38
2 x OutPort_285908 | SOURCEANDSINK | Group: Sanitary 38
Port_285902 | SOURCEANDSINK | Group: Sanitary 38
InPort_285902 | SOURCEANDSINK | Group: Sanitary 38
InPort_287118 | SINK | Group: Sanitary 32
OutPort_287129 | SOURCE | Group: Sanitary 32
Port_287118 | SINK | Group: Sanitary 32
2 x Port_287471 | SOURCEANDSINK | Group: Mechanical URB.RASA. 3
20 x Port_311728 | SOURCEANDSINK
20 x Port_324841 | SOURCEANDSINK
2 x Port_330362 | SOURCEANDSINK | Group: Mechanical URB.RASA. 4
20 x Port_337841 | SOURCEANDSINK
20 x Port_342498 | SOURCEANDSINK
2 x Port_349960 | SOURCEANDSINK | Group: Mechanical URB.RASA. 2
20 x Port_351751 | SOURCEANDSINK
2 x Port_353442 | SOURCEANDSINK | Group: Mechanical URB.RASA. 1
2 x Port_354392 | SOURCEANDSINK | Group: Mechanical URB.RASA. 5
20 x Port_356472 | SOURCEANDSINK
20 x Port_357447 | SOURCEANDSINK
20 x Port_360221 | SOURCEANDSINK
2 x Port_361282 | SOURCEANDSINK | Group: Mechanical URB.RASA. 8
20 x Port_361840 | SOURCEANDSINK
2 x Port_366709 | SOURCEANDSINK | Group: Mechanical URB.RASA. 7
20 x Port_369444 | SOURCEANDSINK
Port_441953 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
InPort_441953 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
2 x OutPort_455992 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
Port_446403 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
InPort_446403 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
OutPort_456093 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
2 x Port_447416 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 24
20 x Port_447913 | SOURCEANDSINK
16 x Port_447995 | SOURCEANDSINK
4 x Port_447995 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 26
2 x Port_453155 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 25
InPort_455791 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
Port_455791 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
Port_456093 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 23
2 x Port_456227 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 27
2 x InPort_467535 | SOURCEANDSINK | Group: Sanitary 15
2 x OutPort_467727 | SOURCEANDSINK | Group: Sanitary 15
2 x OutPort_467557 | SOURCEANDSINK | Group: Sanitary 15
2 x InPort_467551 | SOURCEANDSINK | Group: Sanitary 15
2 x OutPort_467567 | SOURCEANDSINK | Group: Sanitary 15
InPort_467561 | SOURCEANDSINK | Group: Sanitary 15
Port_467561 | SOURCEANDSINK | Group: Sanitary 15
2 x InPort_467593 | SOURCEANDSINK | Group: Sanitary 15
OutPort_467604 | SOURCEANDSINK | Group: Sanitary 15
OutPort_467615 | SOURCEANDSINK | Group: Sanitary 15
2 x InPort_467604 | SOURCEANDSINK | Group: Sanitary 15
2 x OutPort_467728 | SOURCEANDSINK | Group: Sanitary 15
OutPort_467605 | SOURCEANDSINK | Group: Sanitary 15
Port_467605 | SOURCEANDSINK | Group: Sanitary 15
2 x InPort_467609 | SOURCEANDSINK | Group: Sanitary 15
2 x OutPort_467627 | SOURCEANDSINK | Group: Sanitary 15
2 x OutPort_467732 | SOURCEANDSINK | Group: Sanitary 15
InPort_467615 | SOURCEANDSINK | Group: Sanitary 15
2 x OutPort_467733 | SOURCEANDSINK | Group: Sanitary 15
Port_467619 | SOURCEANDSINK | Group: Sanitary 15
InPort_467619 | SOURCEANDSINK | Group: Sanitary 15
2 x InPort_467719 | SOURCEANDSINK | Group: Sanitary 15
InPort_467727 | SOURCEANDSINK | Group: Sanitary 15
InPort_467732 | SOURCEANDSINK | Group: Sanitary 15
2 x Port_468117 | SOURCEANDSINK
2 x Port_468484 | SOURCEANDSINK
2 x Port_468493 | SOURCEANDSINK
2 x Port_468505 | SOURCEANDSINK
2 x Port_468523 | SOURCEANDSINK
8 x Port_479805 | SOURCEANDSINK
8 x Port_481442 | SOURCEANDSINK
2 x Port_481729 | SOURCEANDSINK | Group: Sanitary 39
2 x Port_482118 | SOURCEANDSINK | Group: Sanitary 37
2 x Port_482304 | SOURCEANDSINK | Group: Sanitary 40
InPort_503182 | SOURCEANDSINK | Group: Sanitary 6
2 x OutPort_503186 | SOURCEANDSINK | Group: Sanitary 6
2 x InPort_503183 | SOURCEANDSINK | Group: Sanitary 6
2 x Port_511355 | SOURCEANDSINK | Group: Sanitary 41
InPort_516832 | SOURCEANDSINK | Group: Sanitary 13
Port_516832 | SOURCEANDSINK | Group: Sanitary 13
2 x Port_533153 | SOURCEANDSINK | Group: Mechanical URB.RASA. 6
2 x Port_535852 | SOURCEANDSINK | Group: Mechanical URB.RASA. 15
20 x Port_536744 | SOURCEANDSINK
20 x Port_537864 | SOURCEANDSINK
4 x Port_541112 | SOURCEANDSINK
20 x Port_545310 | SOURCEANDSINK
20 x Port_546969 | SOURCEANDSINK
2 x Port_627658 | SOURCEANDSINK | Group: Sanitary 34
2 x Port_630977 | SOURCEANDSINK | Group: Sanitary 42
Port_634419 | SOURCEANDSINK | Group: Sanitary 22
InPort_634419 | SOURCEANDSINK | Group: Sanitary 22
OutPort_634423 | SOURCEANDSINK | Group: Sanitary 22
InPort_634421 | SOURCEANDSINK | Group: Sanitary 22
2 x OutPort_634758 | SOURCEANDSINK | Group: Sanitary 22
Port_634421 | SOURCEANDSINK | Group: Sanitary 22
InPort_634423 | SOURCEANDSINK | Group: Sanitary 22
OutPort_634627 | SOURCEANDSINK | Group: Sanitary 22
InPort_634627 | SOURCEANDSINK | Group: Sanitary 22
Port_640740 | SOURCEANDSINK | Group: Sanejament - Col·lector nou 28
5 x Port_640740 | SOURCEANDSINK
Port_640740 | SOURCEANDSINK | Group: Sanitary 36
Port_640740 | SOURCEANDSINK | Group: IF.SANE.Pluvial 9
20 x Port_684450 | SOURCEANDSINK
20 x Port_684452 | SOURCEANDSINK
20 x Port_684453 | SOURCEANDSINK

# IfcFlowController: AMB.Perico.4x4.Connexions:AMB_EP_Punt de pas_60x60 (4)
In: N00 (mar)
Type - Classification: 70.40 Instal·lacions i serveis (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40; 105.AMB.ClassificacioDescripcio: Instal·lacions i serveis
Pset_DistributionFlowElementCommon - Reference: AMB.Perico.4x4.Connexions:AMB_EP_Punt de pas_60x60; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Perico.4x4.Connexions: AMB_EP_Punt de pas_60x60; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø
Name (AMB.Perico.4x4.Connexions:AMB_EP_Punt de pas_60x60:...) | 110.AMB.Descripcio | 507.AMB.Area (m2) | 509.AMB.Volum (m3)
356472 | Tel-Existent | 4.51581 | 0.360152
357447 | Tel-Existent | 4.51581 | 0.360152
447995 | Telef-Arqueta | 4.19781 | 0.245152 | 1 AMB.Identificacio - 112.AMB.Servei: Piping System: Sanejament - Col·lector nou; Group: Sanejament - Col·lector nou 26
546969 | Telecos-Arqueta | 4.89781 | 0.490152

# IfcFlowController: AMB.Perico.4x4.Connexions:AMB_EP_Punt de pas_60x60 (12)
In: N00 (mar)
Type - Classification: 70.40 Instal·lacions i serveis (Uniformat); Material: <Unnamed> (21)
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40; 105.AMB.ClassificacioDescripcio: Instal·lacions i serveis
Pset_DistributionFlowElementCommon - Reference: AMB.Perico.4x4.Connexions:AMB_EP_Punt de pas_60x60; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Perico.4x4.Connexions: AMB_EP_Punt de pas_60x60; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø-110 mmø
Name (AMB.Perico.4x4.Connexions:AMB_EP_Punt de pas_60x60:...) | 110.AMB.Descripcio | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Material
311728 | Telecos-Arqueta | 4.89781 | 0.490152
324841 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
337841 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
342498 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
351751 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
360221 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
361840 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
369444 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
447913 | Telef-Arqueta | 4.61781 | 0.392152
536744 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
537864 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>
545310 | Telecos-Arqueta | 4.89781 | 0.490152 | <Unnamed>

# IfcFlowController: AMB.Perico.CL.Rectangular:AMB.CL.Perico.60x60 (10)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40; 105.AMB.ClassificacioDescripcio: Instal·lacions i serveis; 111.AMB.DescripcioTipus: Arqueta d'aigua de 40x40 cm
Classification: 70.40 Instal·lacions i serveis (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.Perico.CL.Rectangular:AMB.CL.Perico.60x60; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Perico.CL.Rectangular: AMB.CL.Perico.60x60; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 110 mmø-110 mmø-110 mmø-110 mmø
Name (AMB.Perico.CL.Rectangular:AMB.CL.Perico.60x60:...) | In | 110.AMB.Descripcio | 507.AMB.Area (m2) | 509.AMB.Volum (m3)
189601 | N00 (mar) | Reg-Arqueta sectorial | 2.54614 | 0.175538
189905 | N00 (mar) | Reg-Arqueta de registre | 2.54614 | 0.175538
192921 | N00 (mar) | Reg-Arqueta de registre | 2.54614 | 0.175538
192933 | N00 (mar) | Reg-Arqueta de registre | 2.54614 | 0.175538
192945 | N00 (mar) | Reg-Arqueta de registre | 2.54614 | 0.175538
192957 | N00 (mar) | Reg-Arqueta de registre | 2.54614 | 0.175538
211412 | N00 (mar) | Reg-Arqueta de registre | 3.62614 | 0.256538
211483 | N00 (mar) | Reg-Arqueta de registre | 3.62614 | 0.256538
212598 | Drenatge i Clavagueram | Reg-Arqueta vàlvula antisifó | 2.54614 | 0.175538 | 1 AMB.Identificacio - 115.AMB.Nivell: Level: Drenatge i Clavagueram
541112 | N00 (mar) | Reg-Arqueta vàlvula de rentat | 2.54614 | 0.175538

# IfcFlowController: AMB_Pericó_Amb 4 accessoris_2x4:Pericó 60x60 (2)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40; 105.AMB.ClassificacioDescripcio: Instal·lacions i serveis
Classification: 70.40 Instal·lacions i serveis (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Pericó_Amb 4 accessoris_2x4:Pericó 60x60; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Pericó_Amb 4 accessoris_2x4: Pericó 60x60; 110.AMB.Descripcio: Enllumenat - Registre; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 125 mmø-125 mmø-125 mmø-125 mmø-125 mmø-125 mmø-125 mmø-125 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.2566 m3
Name (AMB_Pericó_Amb 4 accessoris_2x4:Pericó 60x60:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 507.AMB.Area (m2) | Group
271116 | N00 (mar) | Piping System: Hydronic Supply | Level: N00 (mar) | 3.71822 | Hydronic Supply 2; Sanejament - Col·lector nou 18; Sanejament - Col·lector nou 17
274925 | Drenatge i Clavagueram | Piping System: Sanejament - Col·lector nou | Level: Drenatge i Clavagueram | 3.70665 | Sanejament - Col·lector nou 18

# IfcFlowController: AMB_Reg_Anella:AMB_REG_Anella de reg_25mm (9)
In: Drenatge i Clavagueram
Type - Classification: 70.40.20.20 Accesoris de reg (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.20.20; 105.AMB.ClassificacioDescripcio: Accesoris de reg
Pset_DistributionFlowElementCommon - Reference: AMB_Reg_Anella:AMB_REG_Anella de reg_25mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reg_Anella: AMB_REG_Anella de reg_25mm; 110.AMB.Descripcio: Reg-Sector 1; 112.AMB.Servei: Piping System: Sanitary; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 40 mmø-40 mmø
5 AMB.Geometria - 507.AMB.Area: 0.0999909 m2; 509.AMB.Volum: 0.0015069 m3
Name (AMB_Reg_Anella:AMB_REG_Anella de reg_25mm:...) | Group
184319 | Sanitary 13
191141 | Sanitary 6
191162 | Sanitary 6
191181 | Sanitary 6
202339 | Sanitary 3
202767 | Sanitary 3
202965 | Sanitary 3
203600 | Sanitary 3
511355 | Sanitary 41

# IfcFlowController: AMB_Reg_Boca de reg:AMB_REG_Boca de reg_5m, AMB_Reg_Boca de reg:AMB_REG_Boca de reg_5m:201191
In: N00 (mar)
Type - Classification: 70.40.20.20 Accesoris de reg (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.20.20; 105.AMB.ClassificacioDescripcio: Accesoris de reg
Pset_DistributionFlowElementCommon - Reference: AMB_Reg_Boca de reg:AMB_REG_Boca de reg_5m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reg_Boca de reg: AMB_REG_Boca de reg_5m; 110.AMB.Descripcio: Reg-Boques; 112.AMB.Servei: Piping System: IF.Altres; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 40 mmø
5 AMB.Geometria - 507.AMB.Area: 0.15762 m2; 509.AMB.Volum: 0.00847072 m3
Group: IF.Altres 1

# IfcFlowController: AMB_Reg_Boca de reg:AMB_REG_Boca de reg_5m (2)
In: N00 (mar)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.20.20; 105.AMB.ClassificacioDescripcio: Accesoris de reg
Classification: 70.40.20.20 Accesoris de reg (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Reg_Boca de reg:AMB_REG_Boca de reg_5m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reg_Boca de reg: AMB_REG_Boca de reg_5m; 110.AMB.Descripcio: Reg-Boques; 112.AMB.Servei: Piping System: IF.Altres; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 50 mmø
5 AMB.Geometria - 507.AMB.Area: 0.15762 m2; 509.AMB.Volum: 0.00847072 m3
Name (AMB_Reg_Boca de reg:AMB_REG_Boca de reg_5m:...) | Group
202145 | IF.Altres 2
208006 | IF.Altres 3

# IfcFlowFitting: AMB.Embornal.5Connexions:Embornals (8)
In: Drenatge i Clavagueram
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.20; 105.AMB.ClassificacioDescripcio: Reixes i buneras
Classification: 70.40.30.20 Reixes i buneras (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB.Embornal.5Connexions:Embornals; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Embornal.5Connexions: Embornals; 110.AMB.Descripcio: SN-Embornal caixa; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø
5 AMB.Geometria - 507.AMB.Area: 7.62966 m2; 509.AMB.Volum: 0.416008 m3
Name (AMB.Embornal.5Connexions:Embornals:...)
226588
227705
228031
228546 | 1 AMB.Identificacio - 112.AMB.Servei: Piping System: Sanitary; Group: Sanitary 1; Sanitary 5
235409
246415
260924
261247

# IfcFlowFitting: AMB.Embornal.5Connexions:Embornals individuals (2)
In: Drenatge i Clavagueram
Type - Classification: 70.40.30.20 Reixes i buneras (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.20; 105.AMB.ClassificacioDescripcio: Reixes i buneras
Pset_DistributionFlowElementCommon - Reference: AMB.Embornal.5Connexions:Embornals individuals; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Embornal.5Connexions: Embornals individuals; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø
5 AMB.Geometria - 507.AMB.Area: 7.08564 m2; 509.AMB.Volum: 0.256008 m3
Name (AMB.Embornal.5Connexions:Embornals individuals:...) | 110.AMB.Descripcio
253731 | SN-Embornal caixa reg
255114 | SN-Embornal caixa

# IfcFlowFitting: AMB.Embornal.5Connexions:Embornals individuals, AMB.Embornal.5Connexions:Embornals individuals:252466
In: Drenatge i Clavagueram
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.20; 105.AMB.ClassificacioDescripcio: Reixes i buneras
Classification: 70.40.30.20 Reixes i buneras (Uniformat); Group: Sanitary 10
Pset_DistributionFlowElementCommon - Reference: AMB.Embornal.5Connexions:Embornals individuals; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Embornal.5Connexions: Embornals individuals; 110.AMB.Descripcio: SN-Embornal caixa; 112.AMB.Servei: Piping System: Sanitary; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø
5 AMB.Geometria - 507.AMB.Area: 7.08564 m2; 509.AMB.Volum: 0.256008 m3

# IfcFlowFitting: AMB.Pou.Circular.Superior:AMB.CLUxx.Pou.1,5m (11)
Type - Classification: 50.20.20.50 Arquetes i pous d'evaquació d'aigües (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.50; 105.AMB.ClassificacioDescripcio: Arquetes i pous d'evaquació d'aigües; 109.AMB.CodiTipus: CLUxx; 111.AMB.DescripcioTipus: Pou de 150cm de diàmetre, de gero arrebossat
Pset_DistributionFlowElementCommon - Reference: AMB.Pou.Circular.Superior:AMB.CLUxx.Pou.1,5m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Pou.Circular.Superior: AMB.CLUxx.Pou.1,5m; 119.AMB.FaseCreacio: New Construction
Name (AMB.Pou.Circular.Superior:AMB.CLUxx.Pou.1,5m:...) | In | 110.AMB.Descripcio | 115.AMB.Nivell | 242.AMB.Mida | 501.AMB.Longitud (m) | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
230296 | Drenatge i Clavagueram | SN-Pou | Level: Drenatge i Clavagueram | 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø | 1.5 | 18.9427 | 1.21402 | Sanitary 18; Sanejament - Col·lector nou 3; IF.SANE.Pluvial 7
230644 | Drenatge i Clavagueram | SN-Pou | Level: Drenatge i Clavagueram | 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø | 1.61 | 19.9261 | 1.29322 | Sanejament - Col·lector nou 1; IF.SANE.Pluvial 2; Sanitary 16
242810 | Drenatge i Clavagueram | SN-Pou | Level: Drenatge i Clavagueram | 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø | 1.71 | 20.8202 | 1.36522 | Sanejament - Col·lector nou 5; Sanitary 4; IF.SANE.Pluvial 3
249826 | Drenatge i Clavagueram | SE-Pou | Level: Drenatge i Clavagueram | 400 mmø-400 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø-315 mmø | 2.3 | 26.0952 | 1.79002 | Sanejament - Col·lector nou 8; IF.SANE.Pluvial 1; Sanitary 24
255589 | Drenatge i Clavagueram | SN-Pou | Level: Drenatge i Clavagueram | 400 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø-315 mmø | 1.6 | 19.8367 | 1.28602 | Sanejament - Pous i col·lector 1; Sanitary 26; IF.SANE.Pluvial 6; Sanejament - Col·lector nou 9
257688 | Drenatge i Clavagueram | SN-Pou | Level: Drenatge i Clavagueram | 400 mmø-400 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø-315 mmø | 1.76 | 21.2672 | 1.40122 | Sanejament - Col·lector nou 11; Sanejament - Col·lector nou 10; IF.SANE.Pluvial 8; Sanitary 28
262787 | N00 (mar) | SE-Pou |  | 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø | 2.3 | 26.0952 | 1.79002
263070 | Drenatge i Clavagueram | SE-Pou | Level: Drenatge i Clavagueram | 400 mmø-400 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø-315 mmø | 2.27 | 25.827 | 1.76842 | Sanejament - Col·lector nou 13; Sanitary 30; IF.SANE.Pluvial 5
479805 | N00 (mar) | SN-Pou dren |  | 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø | 1.5 | 18.9427 | 1.21402
481442 | N00 (mar) | SN-Pou dren |  | 315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø | 1.5 | 18.9427 | 1.21402
640740 | Drenatge i Clavagueram | SN-Pou | Level: Drenatge i Clavagueram | 400 mmø-315 mmø-315 mmø-315 mmø-315 mmø-315 mmø-200 mmø-315 mmø | 1.3 | 17.1545 | 1.07002 | IF.SANE.Pluvial 9; Sanitary 36; Sanejament - Col·lector nou 28

# IfcFlowFitting: AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B, AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B:634423
In: Drenatge i Clavagueram
Type - Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Codo_PVC_L2: UNE-EN 1329-1_Serie B; 110.AMB.Descripcio: SN-Connexió reixa/embornal; 112.AMB.Servei: Piping System: Sanitary; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 110 mmø-110 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.00206011 m3
Group: Sanitary 22

# IfcFlowFitting: AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B (70)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Codo_PVC_L2: UNE-EN 1329-1_Serie B; 119.AMB.FaseCreacio: New Construction
Name (AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B:...) | In | 110.AMB.Descripcio | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
191077 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000247654 | Sanitary 13
191109 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000322655 | Sanitary 13
191115 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000336861 | Sanitary 13
191244 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000347372 | Sanitary 6
191261 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000356145 | Sanitary 6
191278 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000351823 | Sanitary 6
191284 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000379584 | Sanitary 6
191306 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000374772 | Sanitary 6
191319 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000353415 | Sanitary 6
191363 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000445298 | Sanitary 6
191365 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000460475 | Sanitary 6
193795 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000341413 | Sanitary 13
193816 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.000037422 | Sanitary 13
201654 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000525292 | Sanitary 11
201667 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000525292 | Sanitary 11
201699 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000562084 | Sanitary 11
201708 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000657931 | Sanitary 11
201735 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000630185 | Sanitary 11
201766 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000715249 | Sanitary 11
201791 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000695596 | Sanitary 11
201808 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000741375 | Sanitary 11
201817 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000687154 | Sanitary 11
201834 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000731977 | Sanitary 11
201843 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000690264 | Sanitary 11
201995 | N00 (mar) | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø-50 mmø | 0.0000821029 | IF.Altres 1
202003 | N00 (mar) | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø-50 mmø | 0.000116371 | IF.Altres 1
202014 | N00 (mar) | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø-50 mmø | 0.000056402 | IF.Altres 1
202516 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000254238 | Sanitary 3
203375 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000253606 | Sanitary 3
203379 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000265373 | Sanitary 3
203794 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000337647 | Sanitary 3
203799 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000325173 | Sanitary 3
204611 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000766981 | Sanitary 11
206558 | Drenatge i Clavagueram | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000906698 | IF.Altres 2
206571 | Drenatge i Clavagueram | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000992368 | IF.Altres 2
206973 | Drenatge i Clavagueram | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.000116371 | IF.Altres 2
206977 | Drenatge i Clavagueram | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.000116371 | IF.Altres 2
206989 | Drenatge i Clavagueram | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000882717 | IF.Altres 2
206993 | Drenatge i Clavagueram | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000502452 | IF.Altres 2
208808 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000420367 | Sanitary 6
211963 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000485472 | Sanitary 31
211972 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000687833 | Sanitary 31
212153 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000244929 | Sanitary 12
212551 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000317785 | Sanitary 3
213402 | Drenatge i Clavagueram | Reg-Principal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 75 mmø-75 mmø | 0.000653262 | Sanitary 7
213651 | Drenatge i Clavagueram | Reg-Principal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 75 mmø-75 mmø | 0.00065565 | Sanitary 7
213711 | Drenatge i Clavagueram | Reg-Principal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 75 mmø-75 mmø | 0.000256025 | Sanitary 7
279065 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000821218 | Sanitary 3
279516 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000756047 | Sanitary 11
279518 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000807448 | Sanitary 11
280467 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000308857 | Sanitary 3
280469 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.000035217 | Sanitary 23
281967 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000385735 | Sanitary 6
281993 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000848884 | Sanitary 14
282937 | N00 (mar) | Reg-Boques | Piping System: Sanitary | Level: N00 (mar) | 50 mmø-50 mmø | 0.000193474 | IF.Altres 3; Sanitary 32
283082 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000521032 | Sanitary 14
284059 | N00 (mar) | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø-50 mmø | 0.0000621813 | IF.Altres 1
285908 | Drenatge i Clavagueram | Dren-Tub | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø-110 mmø | 0.000603448 | Sanitary 38
286859 | N00 (mar) | Reg-Boques | Piping System: Sanitary | Level: N00 (mar) | 50 mmø-50 mmø | 0.000141313 | Sanitary 32
287129 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000512098 | Sanitary 32
467557 | Drenatge i Clavagueram | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø-100 mmø | 0.00322757 | Sanitary 15
467567 | Drenatge i Clavagueram | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø-100 mmø | 0.00322336 | Sanitary 15
467615 | Drenatge i Clavagueram | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø-100 mmø | 0.00282236 | Sanitary 15
467627 | Drenatge i Clavagueram | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø-100 mmø | 0.00322128 | Sanitary 15
503186 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000596195 | Sanitary 6
503207 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000595794 | Sanitary 6
506833 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000790923 | Sanitary 6
516846 | Drenatge i Clavagueram | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø-40 mmø | 0.0000352469 | Sanitary 13
614297 | Drenatge i Clavagueram | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø-50 mmø | 0.0000607304 | Sanitary 31
634758 | Drenatge i Clavagueram | SN-Connexió reixa/embornal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø-110 mmø | 0.000776818 | Sanitary 22

# IfcFlowFitting: AMB_Injerto_PVC_L2:UNE-EN 1329-1_Serie B (2)
In: Drenatge i Clavagueram
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Injerto_PVC_L2:UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Injerto_PVC_L2: UNE-EN 1329-1_Serie B; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
Name (AMB_Injerto_PVC_L2:UNE-EN 1329-1_Serie B:...) | 110.AMB.Descripcio | 112.AMB.Servei | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
206971 | Reg-Boques | Piping System: IF.Altres | 50 mmø-50 mmø | 0.000196753 | Sanitary 11; IF.Altres 2
506837 | Reg-Sector 1 | Piping System: Sanitary | 40 mmø-40 mmø | 0.000131155 | Sanitary 6

# IfcFlowFitting: AMB_Reducción_PVC_L2:UNE-EN 1329-1_Serie B (6)
In: Drenatge i Clavagueram
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat); Group: Sanitary 7
Pset_DistributionFlowElementCommon - Reference: AMB_Reducción_PVC_L2:UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reducción_PVC_L2: UNE-EN 1329-1_Serie B; 110.AMB.Descripcio: Reg-Principal; 112.AMB.Servei: Piping System: Sanitary; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 75 mmø-63 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000280929 m3
Name (AMB_Reducción_PVC_L2:UNE-EN 1329-1_Serie B:...)
511026
511028
511047
511068
511070
511098

# IfcFlowFitting: AMB_Te_PVC_L2:UNE-EN 1329-1_Serie B (3)
In: Drenatge i Clavagueram
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat); Group: Sanitary 15
Pset_DistributionFlowElementCommon - Reference: AMB_Te_PVC_L2:UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Te_PVC_L2: UNE-EN 1329-1_Serie B; 110.AMB.Descripcio: Aigua-Nova canonada; 112.AMB.Servei: Piping System: Sanitary; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 100 mmø-100 mmø-100 mmø
Name (AMB_Te_PVC_L2:UNE-EN 1329-1_Serie B:...) | 509.AMB.Volum (m3)
467604 | 0.00383268
467727 | 0.00383267
467732 | 0.00383268

# IfcFlowFitting: AMB_Unión_PVC_L2:UNE-EN 1329-1_Serie B, AMB_Unión_PVC_L2:UNE-EN 1329-1_Serie B:614291
In: Drenatge i Clavagueram
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat); Group: Sanitary 31
Pset_DistributionFlowElementCommon - Reference: AMB_Unión_PVC_L2:UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Unión_PVC_L2: UNE-EN 1329-1_Serie B; 110.AMB.Descripcio: Reg-Boques; 112.AMB.Servei: Piping System: Sanitary; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 50 mmø-50 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.0000981701 m3

# IfcFlowSegment: Conduit without Fittings:Conduit (5)
In: Drenatge i Clavagueram
Type - Pset_ProductRequirements - Category: Conduits
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.60; 105.AMB.ClassificacioDescripcio: Cablejat elèctric
Classification: 50.60.30.60 Cablejat elèctric (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conduit without Fittings:Conduit; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 29.3615 m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Conduit without Fittings: Conduit; 110.AMB.Descripcio: SE-BT; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
5 AMB.Geometria - 501.AMB.Longitud: 29.3615 m; sets with these values: 2
Name (Conduit without Fittings:Conduit:...)
468117
468484
468493
468505
468523

# IfcFlowSegment: Flex Duct Rectangular:AMB.EP.Rasa.Rectangular (9)
In: Drenatge i Clavagueram
Type - Pset_ElementShading - Roughness: 0.00009144 m
Type - Pset_ProductRequirements - Category: Flex Ducts
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 10.20.20.10; 105.AMB.ClassificacioDescripcio: Excavació general; 109.AMB.CodiTipus: EP_R40x50_TERRA; 111.AMB.DescripcioTipus: Cannalització d'Enllumenat Públic en rasa de 40x50cm (amb mitjans mecànics i manuals), reblert amb terres de la pròpia excavació, inclou banda de senyalització, 2 tubs corrugats de 90mm, 1 conductor RVFV 4x6mm2 i conductor de terra nu de 35mm2.
Type - 2 AMB.Caracteristiques - 231.AMB.TubsNombre: 4; 233.AMB.Formigonada: yes
Classification: 10.20.20.10 Excavació general (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Flex Duct Rectangular:AMB.EP.Rasa.Rectangular; sets with these values: 2

Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowSegment: Flex Duct Rectangular:AMB.EP.Rasa.Rectangular (9)
Pset_DuctSegmentTypeCommon - sets with these values: 3
1 AMB.Identificacio - 107.AMB.NomTipus: Flex Duct Rectangular: AMB.EP.Rasa.Rectangular; 110.AMB.Descripcio: Telecos-Prisma formigonat; 112.AMB.Servei: Duct System: URB.RASA.; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 500 mmx500 mm
5 AMB.Geometria - 502.AMB.Amplada: 0.5 m; 503.AMB.Altura: 0.5 m; sets with these values: 2
Name (Flex Duct Rectangular:AMB.EP.Rasa.Rectangular:...) | Length (m) = 501.AMB.Longitud (m) | Group
287471 | 7.11875 | Mechanical URB.RASA. 3
330362 | 7.48244 | Mechanical URB.RASA. 4
349960 | 35.1121 | Mechanical URB.RASA. 2
353442 | 38.6667 | Mechanical URB.RASA. 1
354392 | 2.22545 | Mechanical URB.RASA. 5
361282 | 4.83155 | Mechanical URB.RASA. 8
366709 | 70.5242 | Mechanical URB.RASA. 7
533153 | 6.68819 | Mechanical URB.RASA. 6
535852 | 6.85617 | Mechanical URB.RASA. 15

# IfcFlowSegment: Flex Pipe Round:Flex - Round (17)
Type - Pset_ElementShading - Roughness: 0.00004572 m
Type - Pset_ProductRequirements - Category: Flex Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.40; 105.AMB.ClassificacioDescripcio: Mànegues i tubs de distribució elèctrica
Classification: 50.60.30.40 Mànegues i tubs de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Flex Pipe Round:Flex - Round; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Flex Pipe Round: Flex - Round; 112.AMB.Servei: Piping System: Sanejament - Col·lector nou; 119.AMB.FaseCreacio: New Construction
Name (Flex Pipe Round:Flex - Round:...) | In | Length (m) = 501.AMB.Longitud (m) | 110.AMB.Descripcio | 115.AMB.Nivell | 242.AMB.Mida | 505.AMB.Diametre (m) | Group
264421 | N00 (mar) | 18.697 | Enllumenat-Corrugat | Level: N00 (mar) | 90 mmø | 0.09 | Sanejament - Col·lector nou 14
264725 | N00 (mar) | 19.0817 | Enllumenat-Corrugat | Level: N00 (mar) | 90 mmø | 0.09 | Sanejament - Col·lector nou 15
264750 | Drenatge i Clavagueram | 19.2081 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 16
264756 | Drenatge i Clavagueram | 14.9346 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 17
274627 | Drenatge i Clavagueram | 4.68478 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 110 mmø | 0.11 | Sanejament - Col·lector nou 18
277700 | Drenatge i Clavagueram | 4.69203 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 110 mmø | 0.11 | Sanejament - Col·lector nou 18
278677 | Drenatge i Clavagueram | 9.7074 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 18
278778 | Drenatge i Clavagueram | 17.7323 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 19
278915 | Drenatge i Clavagueram | 17.9927 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 20
278920 | Drenatge i Clavagueram | 19.4185 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 21
278937 | Drenatge i Clavagueram | 24.1502 | Enllumenat-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 22
447416 | Drenatge i Clavagueram | 13.687 | Telef-Corrugat | Level: Drenatge i Clavagueram | 110 mmø | 0.11 | Sanejament - Col·lector nou 24
453155 | Drenatge i Clavagueram | 13.6623 | Telef-Corrugat | Level: Drenatge i Clavagueram | 110 mmø | 0.11 | Sanejament - Col·lector nou 25
455791 | Drenatge i Clavagueram | 1.68268 | Telef-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 23
455992 | Drenatge i Clavagueram | 0.87327 | Telef-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 23
456093 | Drenatge i Clavagueram | 1.38255 | Telef-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 23
456227 | Drenatge i Clavagueram | 1.57096 | Telef-Corrugat | Level: Drenatge i Clavagueram | 90 mmø | 0.09 | Sanejament - Col·lector nou 27

# IfcFlowSegment: Pipe Types:AMB_Plàstic.PVC (88)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.20.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de reg
Classification: 70.40.20.10 Canalitzacions de reg (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB_Plàstic.PVC; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00000254 m
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB_Plàstic.PVC; 119.AMB.FaseCreacio: New Construction
Name (Pipe Types:AMB_Plàstic.PVC:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 110.AMB.Descripcio | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
191075 | Drenatge i Clavagueram | 0.0565 | 8.68999 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.0071 | 0.04 | Sanitary 13
191083 | Drenatge i Clavagueram | 7.06863 | 8.68999 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.88827 | 0.04 | Sanitary 13
191095 | Drenatge i Clavagueram | 0.812919 | 8.68998 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.102154 | 0.04 | Sanitary 13
191107 | Drenatge i Clavagueram | 0.0611381 | 8.68998 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00768284 | 0.04 | Sanitary 13
191194 | Drenatge i Clavagueram | 7.90417 | 8.68919 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.993267 | 0.04 | Sanitary 6
191231 | Drenatge i Clavagueram | 1.67879 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.210963 | 0.04 | Sanitary 6
191242 | Drenatge i Clavagueram | 0.0595369 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00748163 | 0.04 | Sanitary 6
191248 | Drenatge i Clavagueram | 4.53423 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.569788 | 0.04 | Sanitary 6
191264 | Drenatge i Clavagueram | 1.91042 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.24007 | 0.04 | Sanitary 6
191276 | Drenatge i Clavagueram | 0.0593586 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00745922 | 0.04 | Sanitary 6
191293 | Drenatge i Clavagueram | 2.72765 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.342767 | 0.04 | Sanitary 6
191304 | Drenatge i Clavagueram | 0.0584172 | 8.75447 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00734092 | 0.04 | Sanitary 6
191309 | Drenatge i Clavagueram | 19.3292 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 2.42897 | 0.04 | Sanitary 6
191322 | Drenatge i Clavagueram | 2.34893 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.295175 | 0.04 | Sanitary 6
191353 | Drenatge i Clavagueram | 0.36521 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.0458937 | 0.04 | Sanitary 6
193522 | Drenatge i Clavagueram | 0.0651456 | 8.68999 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00818644 | 0.04 | Sanitary 13
193784 | Drenatge i Clavagueram | 0.0427907 | 8.68999 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00537724 | 0.04 | Sanitary 13
193797 | Drenatge i Clavagueram | 8.73897 | 8.68999 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 1.09817 | 0.04 | Sanitary 13
193888 | Drenatge i Clavagueram | 0.335194 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.0526522 | 0.05 | Sanitary 11
201603 | Drenatge i Clavagueram | 0.604088 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.0948899 | 0.05 | Sanitary 11
201621 | Drenatge i Clavagueram | 0.0942572 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.0148059 | 0.05 | Sanitary 11
201641 | Drenatge i Clavagueram | 8.64524 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 1.35799 | 0.05 | Sanitary 11
201669 | Drenatge i Clavagueram | 0.402293 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.063192 | 0.05 | Sanitary 11
201689 | Drenatge i Clavagueram | 7.05488 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 1.10818 | 0.05 | Sanitary 11
201719 | Drenatge i Clavagueram | 0.861126 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.135265 | 0.05 | Sanitary 11
201752 | Drenatge i Clavagueram | 8.42063 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 1.32271 | 0.05 | Sanitary 11
201769 | Drenatge i Clavagueram | 1.64493 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.258386 | 0.05 | Sanitary 11
201794 | Drenatge i Clavagueram | 4.57825 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.71915 | 0.05 | Sanitary 11
201802 | Drenatge i Clavagueram | 1.90847 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.299782 | 0.05 | Sanitary 11
201820 | Drenatge i Clavagueram | 0.230133 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.0361491 | 0.05 | Sanitary 11
201828 | Drenatge i Clavagueram | 2.71513 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.426491 | 0.05 | Sanitary 11
201837 | Drenatge i Clavagueram | 19.5461 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 3.0703 | 0.05 | Sanitary 11
202017 | N00 (mar) | 0.893138 | 8.63959 | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø | 0.140294 | 0.05 | IF.Altres 1
202259 | Drenatge i Clavagueram | 9.48236 | 8.49897 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 1.19159 | 0.04 | Sanitary 6
202498 | Drenatge i Clavagueram | 0.998923 | 8.43173 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.125528 | 0.04 | Sanitary 3
202514 | Drenatge i Clavagueram | 0.0632899 | 8.43173 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00795324 | 0.04 | Sanitary 3
202919 | Drenatge i Clavagueram | 16.3136 | 8.43173 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 2.05002 | 0.04 | Sanitary 3
203327 | Drenatge i Clavagueram | 0.0130795 | 8.43173 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00164362 | 0.04 | Sanitary 3
203338 | Drenatge i Clavagueram | 0.0633081 | 8.43174 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00795554 | 0.04 | Sanitary 3
203392 | Drenatge i Clavagueram | 8.04551 | 8.43174 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 1.01103 | 0.04 | Sanitary 3
203488 | Drenatge i Clavagueram | 7.89853 | 8.43188 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.992559 | 0.04 | Sanitary 3
203775 | Drenatge i Clavagueram | 0.0320006 | 8.43188 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00402132 | 0.04 | Sanitary 3
203786 | Drenatge i Clavagueram | 0.128423 | 8.43188 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.0161381 | 0.04 | Sanitary 3
206536 | Drenatge i Clavagueram | 0.302736 | 8.75183 | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø | 0.0475537 | 0.05 | IF.Altres 2
206544 | Drenatge i Clavagueram | 0.0088376 | 8.68952 | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø | 0.00138821 | 0.05 | IF.Altres 2
206562 | Drenatge i Clavagueram | 0.00549006 | 8.64506 | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø | 0.000862377 | 0.05 | IF.Altres 2
206792 | Drenatge i Clavagueram | 0.246039 | 8.63338 | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø | 0.0386477 | 0.05 | IF.Altres 2
206963 | Drenatge i Clavagueram | 0.173041 | 8.68113 | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø | 0.0271812 | 0.05 | IF.Altres 2
206964 | Drenatge i Clavagueram | 0.00609634 | 8.66154 | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø | 0.00095761 | 0.05 | IF.Altres 2
206965 | Drenatge i Clavagueram | 0.0545686 | 8.63338 | Reg-Boques | Piping System: IF.Altres | Level: Drenatge i Clavagueram | 50 mmø | 0.00857162 | 0.05 | IF.Altres 2
208608 | Drenatge i Clavagueram | 0.113833 | 8.75447 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.0143047 | 0.04 | Sanitary 6
208746 | Drenatge i Clavagueram | 0.958872 | 8.75447 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.120495 | 0.04 | Sanitary 6
209805 | Drenatge i Clavagueram | 2.81258 | 8.68498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.441799 | 0.05 | Sanitary 11
210262 | Drenatge i Clavagueram | 0.780727 | 8.68113 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.122636 | 0.05 | Sanitary 14
210271 | Drenatge i Clavagueram | 0.0292407 | 8.69498 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.00459312 | 0.05 | Sanitary 14
210388 | Drenatge i Clavagueram | 1.16557 | 8.4247 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.183087 | 0.05 | Sanitary 31
210398 | Drenatge i Clavagueram | 10.8598 | 8.4247 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 1.70586 | 0.05 | Sanitary 32
211153 | N00 (mar) | 0.599 | 8.5067 | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø | 0.0940907 | 0.05 | IF.Altres 3
211947 | Drenatge i Clavagueram | 9.49125 | 8.43907 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 1.49088 | 0.05 | Sanitary 14
211955 | Drenatge i Clavagueram | 4.92394 | 8.43998 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.773451 | 0.05 | Sanitary 31
211966 | Drenatge i Clavagueram | 0.147438 | 8.43998 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.0231595 | 0.05 | Sanitary 31
212111 | Drenatge i Clavagueram | 5.016 | 8.43173 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.630329 | 0.04 | Sanitary 12
212538 | Drenatge i Clavagueram | 2.75299 | 8.42979 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.345951 | 0.04 | Sanitary 3
212549 | Drenatge i Clavagueram | 0.0607341 | 8.42979 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00763207 | 0.04 | Sanitary 3
212566 | Drenatge i Clavagueram | 0.389063 | 8.42978 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.0488911 | 0.04 | Sanitary 3
212709 | Drenatge i Clavagueram | 0.39233 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.0493017 | 0.04 | Sanitary 6
213079 | Drenatge i Clavagueram | 0.364305 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.0457799 | 0.04 | Sanitary 6
213154 | Drenatge i Clavagueram | 7.70393 | 8.75948 | Reg-Principal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 63 mmø | 1.52477 | 0.063 | Sanitary 7
213384 | Drenatge i Clavagueram | 7.63509 | 8.75948 | Reg-Principal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 63 mmø | 1.51114 | 0.063 | Sanitary 7
213405 | Drenatge i Clavagueram | 8.05325 | 8.76204 | Reg-Principal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 63 mmø | 1.5939 | 0.063 | Sanitary 7
213700 | Drenatge i Clavagueram | 6.01808 | 8.88762 | Reg-Principal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 63 mmø | 1.1911 | 0.063 | Sanitary 7
277728 | Drenatge i Clavagueram | 19.8717 | 8.43173 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 2.49715 | 0.04 | Sanitary 3
277785 | Drenatge i Clavagueram | 19.6175 | 8.42471 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 3.08151 | 0.05 | Sanitary 31
282843 | N00 (mar) | 0.233188 | 8.4247 | Reg-Boques | Piping System: Sanitary | Level: N00 (mar) | 50 mmø | 0.036629 | 0.05 | Sanitary 32
284855 | Drenatge i Clavagueram | 2.855 | 8.25612 | Reg-Desguàs | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 0.986617 | 0.11 | Sanitary 33
285600 | Drenatge i Clavagueram | 37.009 | 8.59856 | Dren-Tub | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 12.7894 | 0.11 | Sanitary 35
285890 | Drenatge i Clavagueram | 0.0465671 | 8.31845 | Dren-Tub | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 0.0160924 | 0.11 | Sanitary 38
285902 | Drenatge i Clavagueram | 0.0227462 | 8.31845 | Dren-Tub | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 0.00786054 | 0.11 | Sanitary 38
287118 | Drenatge i Clavagueram | 0.0679552 | 8.4247 | Reg-Boques | Piping System: Sanitary | Level: Drenatge i Clavagueram | 50 mmø | 0.0106744 | 0.05 | Sanitary 32
481729 | Drenatge i Clavagueram | 1.51401 | 8.76085 | Dren-Tub | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 0.523205 | 0.11 | Sanitary 39
482118 | Drenatge i Clavagueram | 36.9656 | 7.99117 | Dren-Tub | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 12.7744 | 0.11 | Sanitary 37
482304 | Drenatge i Clavagueram | 3.798 | 8.75848 | Dren-Tub | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 1.31249 | 0.11 | Sanitary 40
503182 | Drenatge i Clavagueram | 0.0488138 | 8.75446 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00613412 | 0.04 | Sanitary 6
503183 | Drenatge i Clavagueram | 0.0420396 | 8.71233 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.00528285 | 0.04 | Sanitary 6
516832 | Drenatge i Clavagueram | 0.740929 | 8.68999 | Reg-Sector 1 | Piping System: Sanitary | Level: Drenatge i Clavagueram | 40 mmø | 0.0931079 | 0.04 | Sanitary 13
634419 | Drenatge i Clavagueram | 0.218 | 9.03202 | SN-Connexió reixa/embornal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 0.0753354 | 0.11 | Sanitary 22
634421 | Drenatge i Clavagueram | 1.79561 | 8.77147 | SN-Connexió reixa/embornal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 0.620518 | 0.11 | Sanitary 22
634627 | Drenatge i Clavagueram | 0.119587 | 8.84822 | SN-Connexió reixa/embornal | Piping System: Sanitary | Level: Drenatge i Clavagueram | 110 mmø | 0.0413264 | 0.11 | Sanitary 22

# IfcFlowSegment: Pipe Types:Default (14)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària
Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:Default; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00004572 m
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: Default; 119.AMB.FaseCreacio: New Construction
Name (Pipe Types:Default:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 110.AMB.Descripcio | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
201979 | N00 (mar) | 0.295303 | 8.77534 | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø | 0.0463861 | 0.05 | IF.Altres 1
201987 | N00 (mar) | 0.0182046 | 8.70756 | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø | 0.00285957 | 0.05 | IF.Altres 1
201997 | N00 (mar) | 0.00591489 | 8.65362 | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø | 0.000929109 | 0.05 | IF.Altres 1
202006 | N00 (mar) | 0.0417638 | 8.63778 | Reg-Boques | Piping System: IF.Altres | Level: N00 (mar) | 50 mmø | 0.00656025 | 0.05 | IF.Altres 1
467535 | Drenatge i Clavagueram | 1.06516 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 0.334629 | 0.1 | Sanitary 15
467551 | Drenatge i Clavagueram | 6.89225 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 2.16526 | 0.1 | Sanitary 15
467561 | Drenatge i Clavagueram | 1.201 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 0.377305 | 0.1 | Sanitary 15
467593 | Drenatge i Clavagueram | 8.49973 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 2.67027 | 0.1 | Sanitary 15
467605 | Drenatge i Clavagueram | 4.30476 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 1.35238 | 0.1 | Sanitary 15
467609 | Drenatge i Clavagueram | 1.19396 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 0.375095 | 0.1 | Sanitary 15
467619 | Drenatge i Clavagueram | 7.138 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 2.24247 | 0.1 | Sanitary 15
467719 | Drenatge i Clavagueram | 8.62782 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 2.71051 | 0.1 | Sanitary 15
467728 | Drenatge i Clavagueram | 54.452 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 17.1066 | 0.1 | Sanitary 15
467733 | Drenatge i Clavagueram | 54.4128 | 8.51842 | Aigua-Nova canonada | Piping System: Sanitary | Level: Drenatge i Clavagueram | 100 mmø | 17.0943 | 0.1 | Sanitary 15

# IfcFlowSegment: Pipe Types:PEAD_315 (13)
In: Drenatge i Clavagueram
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:PEAD_315; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00000254 m
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: PEAD_315; 110.AMB.Descripcio: SN-Connexió embornal/pou; 112.AMB.Servei: Piping System: Sanitary; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 315 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.315 m
Name (Pipe Types:PEAD_315:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 507.AMB.Area (m2) | Group
214487 | 0.930305 | 8.35855 | 0.920632 | Sanitary 2
223291 | 6.98735 | 8.41433 | 6.91469 | Sanitary 1
235063 | 0.025817 | 8.49131 | 0.0255486 | Sanitary 17
244456 | 8.2772 | 8.33963 | 8.19113 | Sanitary 19
249013 | 1.34426 | 8.31387 | 1.33028 | Sanitary 43
253014 | 7.04213 | 7.84634 | 6.96891 | Sanitary 10
254925 | 1.02332 | 8.2998 | 1.01268 | Sanitary 25
255019 | 0.0259383 | 8.25919 | 0.0256686 | Sanitary 8
256998 | 1.98254 | 8.30617 | 1.96193 | Sanitary 20
261081 | 7.776 | 8.2436 | 7.69514 | Sanitary 9
262278 | 0.755748 | 8.37185 | 0.747889 | Sanitary 29
627658 | 11.4313 | 8.33587 | 11.3124 | Sanitary 34
630977 | 1.53938 | 7.92421 | 1.52337 | Sanitary 42

# IfcFlowSegment: Pipe Types:PEAD_400 (6)
In: Drenatge i Clavagueram
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:PEAD_400; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00000254 m
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: PEAD_400; 110.AMB.Descripcio: SN-Col·lector; 112.AMB.Servei: Piping System: Sanejament - Col·lector nou; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 400 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.4 m
Name (Pipe Types:PEAD_400:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 507.AMB.Area (m2) | Group
135510 | 14.6145 | 7.77797 | 18.3652 | Sanejament - Pous i col·lector 1
136951 | 15.497 | 7.45649 | 19.4741 | Sanejament - Pous i col·lector 2
177979 | 21.906 | 7.70311 | 27.5279 | Sanejament - Col·lector nou 2
178258 | 15.39 | 7.4147 | 19.3396 | Sanejament - Col·lector nou 4
244039 | 17.4849 | 7.51466 | 21.9721 | Sanejament - Col·lector nou 7
258459 | 26.177 | 7.62786 | 32.895 | Sanejament - Col·lector nou 12

# IfcFlowSegment: Pipe Types:PEAD_500 (3)
In: Drenatge i Clavagueram
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de drenatge
Classification: 70.40.30.10 Canalitzacions de drenatge (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:PEAD_500; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00000254 m
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: PEAD_500; 110.AMB.Descripcio: SE-Col·lector; 112.AMB.Servei: Piping System: Sanejament - Col·lector existent; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
2 AMB.Caracteristiques - 242.AMB.Mida: 500 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.5 m
Name (Pipe Types:PEAD_500:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 507.AMB.Area (m2) | Group
127529 | 19.873 | 6.95963 | 31.2164 | Sanejament - Col·lector existent 1
127547 | 7.97868 | 6.81741 | 12.5329 | Sanejament - Col·lector existent 2
127565 | 9.155 | 6.691 | 14.3806 | Sanejament - Col·lector existent 3

# IfcFlowTerminal: AMB.Columna.Ful.AMB:AMB.EPExx.Columna.Ful.AMB.10.2, AMB.Columna.Ful.AMB:AMB.EPExx.Columna.Ful.AMB.10.2:435550
In: Drenatge i Clavagueram
Type - Classification: 70.40.10.10 Lluminàries i bàculs (Uniformat); Material: AMB.Llum.Blanc, AMB.Metall.Acer.Corten
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.10.10; 105.AMB.ClassificacioDescripcio: Lluminàries i bàculs
Material: AMB.Llum.Blanc, <Unnamed>, AMB.Metall.Acer.Corten
Pset_DistributionFlowElementCommon - Reference: AMB.Columna.Ful.AMB:AMB.EPExx.Columna.Ful.AMB.10.2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Columna.Ful.AMB: AMB.EPExx.Columna.Ful.AMB.10.2; 110.AMB.Descripcio: Enllumenat-Existent; 115.AMB.Nivell: Level: Drenatge i Clavagueram; 119.AMB.FaseCreacio: New Construction
5 AMB.Geometria - 507.AMB.Area: 2.10495 m2; 509.AMB.Volum: 0.0952996 m3

# IfcFlowTerminal: AMB.Columna.Inclinada.Semiesferes1:AMB.EPExx.Columna.Semiesfera.4m.1.Projector 2 (3)
In: N00 (mar)
Type - Classification: 70.40.10.10 Lluminàries i bàculs (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.10.10; 105.AMB.ClassificacioDescripcio: Lluminàries i bàculs
Pset_DistributionFlowElementCommon - Reference: AMB.Columna.Inclinada.Semiesferes1:AMB.EPExx.Columna.Semiesfera.4m.1.Projector 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Columna.Inclinada.Semiesferes1: AMB.EPExx.Columna.Semiesfera.4m.1.Projector 2; 119.AMB.FaseCreacio: New Construction
5 AMB.Geometria - 507.AMB.Area: 1.46816 m2; 509.AMB.Volum: 0.102981 m3
Name (AMB.Columna.Inclinada.Semiesferes1:AMB.EPExx.Columna.Semiesfera.4m.1.Projector 2:...)
675310
684454
684455

# IfcFlowTerminal: AMB.PuntLlum.Fonamentacio1:AMB.EPExx.PuntLlum.Columna.Inclinada.Semiesferes.4m (3)
In: N00 (mar)
Type - Classification: 70.40.10.10 Lluminàries i bàculs (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.10.10; 105.AMB.ClassificacioDescripcio: Lluminàries i bàculs; 111.AMB.DescripcioTipus: Columna cilindrica amb llumenera vial 4m
Pset_DistributionFlowElementCommon - Reference: AMB.PuntLlum.Fonamentacio1:AMB.EPExx.PuntLlum.Columna.Inclinada.Semiesferes.4m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.PuntLlum.Fonamentacio1: AMB.EPExx.PuntLlum.Columna.Inclinada.Semiesferes.4m; 119.AMB.FaseCreacio: New Construction
5 AMB.Geometria - 507.AMB.Area: 1.41232 m2; 509.AMB.Volum: 0.216153 m3
Name (AMB.PuntLlum.Fonamentacio1:AMB.EPExx.PuntLlum.Columna.Inclinada.Semiesferes.4m:...)
684450
684452
684453
